# Keil uVision project ADC.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: ADC +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c LED.c uart1.c uart2.c uart3.c soft_timer.c config.h STC8A.H
